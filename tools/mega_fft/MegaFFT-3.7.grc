<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mega_fft</value></param>
<param><key>author</key><value>Ettus Research</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Standard edition, single-channel</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>Mega FFT</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>actual_center_freq</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.get_center_freq()</value></param>
<param><key>value</key><value>0</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'tune_obj': tune_obj}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>actual_sample_rate</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.get_samp_rate()</value></param>
<param><key>value</key><value>rate</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'requested_sample_rate': requested_sample_rate}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>antennas</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.get_antennas()</value></param>
<param><key>value</key><value>['']</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>any_test_1</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>if self.fft_sink.controller['average']: self.fft_sink.controller['average'] = False; time.sleep(0.25); self.fft_sink.controller['average'] = True;</value></param>
<param><key>value</key><value>test</value></param>
<param><key>first_eval</key><value>none</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'test': test}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>any_test_1_0</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.fft_sink.controller['average'] = True</value></param>
<param><key>value</key><value>any_test_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>first_eval</key><value>none</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'any_test': any_test_1}</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>auto_dc_offset_removal</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Auto DC offset removal</value></param>
<param><key>notebook</key><value>nb_analog, 1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>auto_iq_correction</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>label</key><value>Auto IQ correction</value></param>
<param><key>notebook</key><value>nb_analog, 1</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>clicked_freq</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>clicked_freq_txt</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>clicked_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Clicked freq</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>daughterboard_sensor_names</value></param>
<param><key>block_id</key><value>src</value></param>
<param><key>function_name</key><value>get_sensor_names</value></param>
<param><key>poll_rate</key><value>sensor_interval</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>daughterboard_sensors</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>'\n'.join(map(lambda x: '%s: %s' % (x, str(self.src.get_sensor(x))), self.daughterboard_sensor_names))</value></param>
<param><key>value</key><value>'(none)'</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'daughterboard_sensor_names': daughterboard_sensor_names}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>int(2**decim_idx)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>decim</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Divide base sample rate</value></param>
<param><key>max</key><value>max_decim</value></param>
<param><key>min</key><value>1</value></param>
<param><key>notebook</key><value>nb_rate, 0</value></param>
<param><key>num_steps</key><value>max_decim-1</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>decim_idx</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Decimate current sample rate</value></param>
<param><key>max</key><value>int(math.log(max_decim)/math.log(2))</value></param>
<param><key>min</key><value>0</value></param>
<param><key>notebook</key><value>nb_rate, 0</value></param>
<param><key>num_steps</key><value>int(math.log(max_decim)/math.log(2))</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_any_code_post_eval</key>
<param><key>id</key><value>dont_need_this_now_built_in_to_Any_Code_block</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_ave_probe</value></param>
<param><key>block_id</key><value>fft_sink</value></param>
<param><key>function_name</key><value>win['avg_alpha'] * [1.0/self.fft_sink.win['avg_alpha'],1.0][self.fft_sink.win['average']];</value></param>
<param><key>poll_rate</key><value>5</value></param>
<param><key>value</key><value>ave</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_averaging</value></param>
<param><key>value</key><value>str_to_bool(averaging)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_center_freq</value></param>
<param><key>value</key><value>actual_center_freq * relative_freq</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_max_idx</value></param>
<param><key>block_id</key><value>fft_max_idx_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>probe_interval</value></param>
<param><key>value</key><value>(fft_size/2)*0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_max_idx_norm</value></param>
<param><key>value</key><value>[fft_max_idx,fft_max_idx-fft_size][int(fft_max_idx&gt;(fft_size/2))]</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_max_lvl</value></param>
<param><key>block_id</key><value>fft_max_lvl_probe</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>probe_interval</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>fft_max_lvl_2</value></param>
<param><key>block_id</key><value>fft_max_lvl_probe_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>probe_interval</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_max_lvl_log</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>math.log10([fft_max_lvl,1.0][int(fft_max_lvl==0.0)])*10.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_max_lvl_value</value></param>
<param><key>value</key><value>fft_max_lvl</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_max_lvl_value_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>fft_max_lvl_2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_peak_hold</value></param>
<param><key>value</key><value>str_to_bool(peak_hold)</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>fix_invalid_freq</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>((freq &lt;= freq_range.stop()) and (freq &gt;= freq_range.start())) or self.set_requested_freq_txt(self.src.get_center_freq()); print self.src.get_center_freq()</value></param>
<param><key>value</key><value>None</value></param>
<param><key>first_eval</key><value>post</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq_fine</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>2, 0, 1, 1</value></param>
<param><key>label</key><value>Freq (fine)</value></param>
<param><key>max</key><value>freq_fine_range/2</value></param>
<param><key>min</key><value>-freq_fine_range/2</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>freq_range</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.get_freq_range()</value></param>
<param><key>value</key><value>shd.freq_range(freq,freq+1)</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>gain_default</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>[gain,initial_gain][gain==float('-inf')]</value></param>
<param><key>value</key><value>gain_range.start()</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'initial_gain': initial_gain}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>gain_range</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.get_gain_range()</value></param>
<param><key>value</key><value>shd.gain_range(0,0,0)</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>get_antennas</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>print self.src.get_antennas()</value></param>
<param><key>value</key><value>None</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>has_lo_locked</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>'lo_locked' in self.src.get_sensor_names()</value></param>
<param><key>value</key><value>False</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>initial_gain</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>[gain,gain_range.start() + ((gain_range.stop() - gain_range.start()) * 0.25)][gain==float('-inf')]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'gain_range': gain_range}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>initial_gain_old</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>gain_range.start() + ((gain_range.stop() - gain_range.start()) * 0.25)</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>lo_offset_txt</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>lo_offset</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>4, 0, 1, 1</value></param>
<param><key>label</key><value>LO offset (only for LO offset tuning mode)</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>locked_probe</value></param>
<param><key>block_id</key><value>src</value></param>
<param><key>function_args</key><value>"'lo_locked'"</value></param>
<param><key>function_name</key><value>get_sensor</value></param>
<param><key>poll_rate</key><value>lo_check_interval * float(has_lo_locked)</value></param>
<param><key>value</key><value>'(unknown)'</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_bin_freq</value></param>
<param><key>value</key><value>fft_center_freq + (((1.0*fft_max_idx_norm) / fft_size) * samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_bin_freq_old</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>value</key><value>fft_center_freq + (((1.0*fft_max_idx_norm - (fft_size/2)) / fft_size) * samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_decim</value></param>
<param><key>value</key><value>256</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>motherboard_sensor_names</value></param>
<param><key>block_id</key><value>src</value></param>
<param><key>function_name</key><value>get_mboard_sensor_names</value></param>
<param><key>poll_rate</key><value>sensor_interval</value></param>
<param><key>value</key><value>[]</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>motherboard_sensors</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>'\n'.join(map(lambda x: '%s: %s' % (x, str(self.src.get_mboard_sensor(x))), filter(lambda x: x.find('gps') != 0, self.motherboard_sensor_names)))</value></param>
<param><key>value</key><value>'(none)'</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'motherboard_sensor_names': motherboard_sensor_names}</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>relative_freq</value></param>
<param><key>value</key><value>1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>false</key><value>1</value></param>
<param><key>label</key><value>Baseband Frequency Axis</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>true</key><value>0</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>relative_freq</value></param>
<param><key>choices</key><value>[1, 0]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>7, 0, 1, 1</value></param>
<param><key>label</key><value>Frequency Axis</value></param>
<param><key>labels</key><value>['RF', 'Baseband']</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>relative_time</value></param>
<param><key>choices</key><value>[False, True]</value></param>
<param><key>value</key><value>True</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>Time display</value></param>
<param><key>labels</key><value>['Absolute', 'Relative']</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>requested_freq</value></param>
<param><key>value</key><value>requested_freq_txt + freq_fine</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>requested_freq_txt</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>Requested freq</value></param>
<param><key>max</key><value>[freq_range.stop(), freq_range.start() + 1.0][freq_range.start()==freq_range.stop()]</value></param>
<param><key>min</key><value>freq_range.start()</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
<param><key>num_steps</key><value>[1000,1][freq_range.start()==freq_range.stop()]</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>requested_freq_txt</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>Requested base freq</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>requested_sample_rate</value></param>
<param><key>value</key><value>requested_sample_rate_base / (1.*decim)</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>requested_sample_rate_base</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>rate</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>Requested base sample rate</value></param>
<param><key>notebook</key><value>nb_rate, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(actual_sample_rate)</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>scope_mode</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>value</key><value>0+1</value></param>
<param><key>label</key><value>Scope Mode</value></param>
<param><key>labels</key><value>['Complex', 'Magnitude']</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>scope_mode_2</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>value</key><value>0+1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Scope Mode 2</value></param>
<param><key>labels</key><value>['Complex', 'Magnitude']</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>selected_antenna</value></param>
<param><key>choices</key><value>antennas</value></param>
<param><key>value</key><value>[ [antenna,antennas[0]][antenna not in antennas] ,antennas[0]][antenna=='']</value></param>
<param><key>label</key><value>Antenna</value></param>
<param><key>labels</key><value>[antennas,['(default)']][antennas==('',)]</value></param>
<param><key>notebook</key><value>nb_analog, 0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>selected_antenna_proxy</value></param>
<param><key>value</key><value>selected_antenna</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>selected_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>gain_default</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>max</key><value>[gain_range.stop(), gain_range.start() + 1.0][gain_range.stop()==gain_range.start()]</value></param>
<param><key>min</key><value>gain_range.start()</value></param>
<param><key>notebook</key><value>nb_analog, 0</value></param>
<param><key>num_steps</key><value>[int((abs(gain_range.stop()-gain_range.start())/[gain_range.step(), 1.0][gain_range.step()==0])), 1][gain_range.stop()==gain_range.start()]</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>selected_gain_proxy</value></param>
<param><key>value</key><value>selected_gain</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>set_antenna</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.set_antenna(self.selected_antenna)</value></param>
<param><key>value</key><value>None</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>first_eval</key><value>none</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'selected_antenna': selected_antenna}</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>show_max_freq</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
<param><key>label</key><value>Show max freq</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>show_max_lvl</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0, 2, 1, 1</value></param>
<param><key>label</key><value>Show max level</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_check_box</key>
<param><key>id</key><value>show_stream_tags_chk</value></param>
<param><key>value</key><value>[False, True][show_stream_tags.lower() != 'false']</value></param>
<param><key>false</key><value>False</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>Print stream tags</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>true</key><value>True</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>signal_probe</value></param>
<param><key>block_id</key><value>probe_avg_mag</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>poll_rate</key><value>probe_interval</value></param>
<param><key>value</key><value>0.0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>signal_probe_log</value></param>
<param><key>value</key><value>math.log10([signal_probe,1.0][signal_probe==0.0])*10</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>spec_proxy</value></param>
<param><key>callback_mode</key><value>inline</value></param>
<param><key>code</key><value>if self.spec != "": self.src.set_subdev_spec(self.spec, 0); print self.spec</value></param>
<param><key>value</key><value>None</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>static_locked</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>'"' + str(locked_probe) + '"'</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Locked</value></param>
<param><key>notebook</key><value>nb_info, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>str_to_bool</value></param>
<param><key>value</key><value>lambda x: len(x)&gt;0 and x.lower()[0] not in ['0', 'n', 'f']</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>subdev_spec</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>'[' + self.src.get_subdev_spec().strip() + ']'</value></param>
<param><key>value</key><value>'(unknown)'</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>test</value></param>
<param><key>choices</key><value>[1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Test</value></param>
<param><key>labels</key><value>['Reset FFT average']</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>button</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>time_probe</value></param>
<param><key>block_id</key><value>src</value></param>
<param><key>function_name</key><value>get_time_now</value></param>
<param><key>poll_rate</key><value>sensor_interval</value></param>
<param><key>value</key><value>shd.time_spec_t()</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>tune_mode</value></param>
<param><key>choices</key><value>[0, 1, 2]</value></param>
<param><key>value</key><value>[1,0][lo_offset==0.0]</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>Tune mode</value></param>
<param><key>labels</key><value>['Auto (no LO offset)', 'Auto with LO offset', 'Manual (no DSP)']</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tune_obj</value></param>
<param><key>value</key><value>[requested_freq, shd.tune_request(requested_freq, lo_offset_txt), shd.tune_request(requested_freq, dsp_freq=0, dsp_freq_policy=shd.tune_request.POLICY_MANUAL)][tune_mode]</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>tune_result</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.src.set_center_freq(self.tune_obj)</value></param>
<param><key>value</key><value>shd.tune_result_t()</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'tune_obj': tune_obj}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>update_clock_source</value></param>
<param><key>callback_mode</key><value>inline</value></param>
<param><key>code</key><value>if self.ref != '': self.src.set_clock_source(self.ref, 0); print 'Ref =', self.ref;</value></param>
<param><key>value</key><value>None</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'ref': ref}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>update_time_source</value></param>
<param><key>callback_mode</key><value>inline</value></param>
<param><key>code</key><value>if self.pps != '': self.src.set_time_source(self.pps, 0); print '1 PPS =', self.pps;</value></param>
<param><key>value</key><value>None</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'pps': pps}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>smini_info</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>'%s (\'%s\'), %s' % (self.src.get_smini_info().get('mboard_id'), self.src.get_smini_info().get('mboard_name'), self.src.get_smini_info().get('rx_subdev_name'))</value></param>
<param><key>value</key><value>'(unknown)'</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>smini_info_all</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>',\n'.join(map(lambda x: '%s: %s'%(x,self.src.get_smini_info().get(x)), self.src.get_smini_info().keys()))</value></param>
<param><key>value</key><value>'(unknown)'</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>variable_any_code_auto_dc_offset_removal</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>[self.src.set_auto_dc_offset(self.auto_dc_offset_removal), self.auto_dc_offset_removal or self.src.set_dc_offset(0+0j)]</value></param>
<param><key>value</key><value>None</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'auto_dc_offset_removal': auto_dc_offset_removal}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>variable_any_code_fft_sink_ave</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.fft_sink.win['average'] = fft_averaging</value></param>
<param><key>value</key><value>fft_averaging</value></param>
<param><key>first_eval</key><value>post</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'averaging': fft_averaging}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>variable_any_code_fft_sink_peak_hold</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.fft_sink.win['peak_hold'] = fft_peak_hold</value></param>
<param><key>value</key><value>fft_peak_hold</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'peak_hold': fft_peak_hold}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>variable_any_code_iq_correction</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>[self.src.set_auto_iq_balance(self.auto_iq_correction), self.auto_iq_correction or self.src.set_iq_balance(0+0j)]</value></param>
<param><key>value</key><value>None</value></param>
<param><key>first_eval</key><value>inline</value></param>
<param><key>injection</key><value>plain</value></param>
<param><key>deps</key><value>{'auto_iq_correction': auto_iq_correction}</value></param>
</block>
<block>
<key>variable_any_code</key>
<param><key>id</key><value>variable_any_code_waterfall_ave</value></param>
<param><key>callback_mode</key><value>post</value></param>
<param><key>code</key><value>self.waterfall_sink.win['average'] = fft_averaging</value></param>
<param><key>value</key><value>fft_averaging</value></param>
<param><key>first_eval</key><value>post</value></param>
<param><key>injection</key><value>variable</value></param>
<param><key>deps</key><value>{'averaging': fft_averaging}</value></param>
</block>
<block>
<key>variable_config</key>
<param><key>id</key><value>variable_config_0</value></param>
<param><key>config_file</key><value>default</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>option</key><value>key</value></param>
<param><key>section</key><value>main</value></param>
<param><key>type</key><value>real</value></param>
<param><key>writeback</key><value>None</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_actual_center_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>actual_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Actual center frequency</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_actual_dsp_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>tune_result.actual_dsp_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>6, 0, 1, 1</value></param>
<param><key>label</key><value>Actual DSP freq</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_actual_sample_rate</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>actual_sample_rate</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
<param><key>label</key><value>Actual</value></param>
<param><key>notebook</key><value>nb_rate, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_fft_max_idx</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>fft_max_idx</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Idx</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_fft_max_lvl_log</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>fft_max_lvl</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Peak magnitude (dB)</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_fft_window_name</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>window_fn_name_map[window]</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>FFT window</value></param>
<param><key>notebook</key><value>nb_info, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_gain_range</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>gain_range.to_pp_string().strip()</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Gain Range</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_level_probe</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>signal_probe_log</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Signal mag^2 (dB)</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_max_bin_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>max_bin_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>label</key><value>Peak freq</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_requested_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>requested_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>3, 0, 1, 1</value></param>
<param><key>label</key><value>Requested base + fine freq</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_rf_freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>tune_result.actual_rf_freq</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>5, 0, 1, 1</value></param>
<param><key>label</key><value>Actual RF freq</value></param>
<param><key>notebook</key><value>nb_freq, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_subdev_spec</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>subdev_spec</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 0, 1, 1</value></param>
<param><key>label</key><value>Sub-device</value></param>
<param><key>notebook</key><value>nb_info, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>motherboard_sensors</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>label</key><value>Motherboard</value></param>
<param><key>notebook</key><value>nb, 3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_text_0_0</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>daughterboard_sensors</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>2, 0, 1, 1</value></param>
<param><key>label</key><value>Daughterboard</value></param>
<param><key>notebook</key><value>nb, 3</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_time_now</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>str( [time.ctime(time_probe.get_real_secs()), datetime.timedelta(seconds=time_probe.get_real_secs()), time.gmtime(time_probe.get_real_secs())] [relative_time])</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 2</value></param>
<param><key>label</key><value>Time now</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>variable_static_smini_info</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>value</key><value>smini_info</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1*10</value></param>
<param><key>label</key><value>SMINI</value></param>
<param><key>notebook</key><value>nb_info, 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_fn</value></param>
<param><key>value</key><value>window_fn_map[window]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_fn_map</value></param>
<param><key>value</key><value>{'auto': None, 'bh': fft_win.blackmanharris, 'ham': fft_win.hamming, 'han': fft_win.hanning, 'rect': fft_win.rectangular, 'flat': fft_win.flattop}</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>window_fn_name_map</value></param>
<param><key>value</key><value>{'auto': 'Auto', 'bh': 'Blackman-Harris', 'ham': 'Hamming', 'han': 'Hanning', 'rect': 'Rectangular', 'flat': 'Flattop'}</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>label</key><value>Antenna (blank for default)</value></param>
<param><key>short_id</key><value>A</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>SHD device args</value></param>
<param><key>short_id</key><value>a</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ave</value></param>
<param><key>label</key><value>Average FFT</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1*0 + 0.5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>averaging</value></param>
<param><key>label</key><value>Enable FFT averaging</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>baz_time_panel</key>
<param><key>id</key><value>baz_time_panel_0</value></param>
<param><key>mode</key><value>auto</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>grid_pos</key><value>1, 2, 1, 2</value></param>
<param><key>ignore_next_trigger</key><value>['rx_rate', 'rx_freq']</value></param>
<param><key>item_size</key><value>8</value></param>
<param><key>notebook</key><value>nb_test, 0</value></param>
<param><key>relative</key><value>relative_time</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>rate</key><value>4</value></param>
</block>
<block>
<key>blks2_logpwrfft_x</key>
<param><key>id</key><value>blks2_logpwrfft_x_0</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>fft_ave_probe</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>frame_rate</key><value>fft_rate</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0</value></param>
<param><key>input_index</key><value>scope_mode</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>scope_mode</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>input_index</key><value>0</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>num_outputs</key><value>2</value></param>
<param><key>output_index</key><value>scope_mode_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_selector</key>
<param><key>id</key><value>blks2_selector_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>input_index</key><value>scope_mode_2</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>num_outputs</key><value>1</value></param>
<param><key>output_index</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_argmax_xx</key>
<param><key>id</key><value>blocks_argmax_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_max_xx</key>
<param><key>id</key><value>blocks_max_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>vlen</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_size</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>display</key><value>show_stream_tags_chk</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw</value></param>
<param><key>label</key><value>Daughterboard bandwidth (where appropriate)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dyn_rng</value></param>
<param><key>label</key><value>Dynamic Range</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>130</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>fft_max_idx_probe</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>fft_max_idx_probe_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>fft_max_lvl_probe</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>fft_max_lvl_probe_2</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_rate</value></param>
<param><key>label</key><value>FFT Rate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_ref_scale</value></param>
<param><key>label</key><value>FFT Ref Scale (p2p)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fft_sink</value></param>
<param><key>avg_alpha</key><value>ave</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fft_center_freq</value></param>
<param><key>fft_size</key><value>1024*0 + fft_size</value></param>
<param><key>freqvar</key><value>clicked_freq</value></param>
<param><key>freq_of_interest</key><value>float('inf')</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>ref_lvl</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>fft_rate</key><value>fft_rate</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold_level</key><value>float('inf')</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window_fn</value></param>
<param><key>y_divs</key><value>int(dyn_rng/10)</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fft_sink_2</value></param>
<param><key>avg_alpha</key><value>ave</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fft_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_size</key><value>1024*0 + fft_size</value></param>
<param><key>freqvar</key><value>clicked_freq</value></param>
<param><key>freq_of_interest</key><value>[None,max_bin_freq][show_max_freq]</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>ref_lvl</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>fft_rate</key><value>fft_rate</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold_level</key><value>[None,fft_max_lvl_value][show_max_lvl]</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window_fn</value></param>
<param><key>y_divs</key><value>int(dyn_rng/10)</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fft_sink_two</value></param>
<param><key>avg_alpha</key><value>ave</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fft_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_size</key><value>1024*0 + fft_size</value></param>
<param><key>freqvar</key><value>clicked_freq</value></param>
<param><key>freq_of_interest</key><value>float('inf')</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>ref_lvl</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>fft_rate</key><value>fft_rate</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold_level</key><value>[None,fft_max_lvl_value_2][show_max_lvl]</value></param>
<param><key>title</key><value>FFT Plot 2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window_fn</value></param>
<param><key>y_divs</key><value>int(dyn_rng/10)</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fft_sink_two_1</value></param>
<param><key>avg_alpha</key><value>ave</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fft_center_freq</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_size</key><value>1024*0 + fft_size</value></param>
<param><key>freqvar</key><value>clicked_freq</value></param>
<param><key>freq_of_interest</key><value>float('inf')</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 0</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>ref_lvl</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>fft_rate</key><value>fft_rate</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>threshold_level</key><value>float('inf')</value></param>
<param><key>title</key><value>FFT Plot 2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window_fn</value></param>
<param><key>y_divs</key><value>int(dyn_rng/10)</value></param>
<param><key>y_per_div</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>label</key><value>FFT Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1024</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>[fft_win.blackmanharris(fft_size),window_fn][int(window_fn!=None)]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>short_id</key><value>f</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0 + 100e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_fine_range</value></param>
<param><key>label</key><value>Fine frequency slider range</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain (default '-inf' selects relative gain of 25%)</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>float("-inf")</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_auto</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>Gain</value></param>
<param><key>short_id</key><value>g</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>gain_range.start() + ((gain_range.stop() - gain_range.start()) * 0.25)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from gnuradio.fft import window as fft_win</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import time, datetime</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_math</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_check_interval</value></param>
<param><key>label</key><value>LO lock check frequency (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lo_offset</value></param>
<param><key>label</key><value>LO offset (selects LO offset tuning mode)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>fft_ave_probe</value></param>
<param><key>average</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>frame_rate</key><value>fft_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0_0</value></param>
<param><key>avg_alpha</key><value>fft_ave_probe</value></param>
<param><key>average</key><value>False</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_size</key><value>fft_size</value></param>
<param><key>frame_rate</key><value>fft_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mag_alpha</value></param>
<param><key>label</key><value>Signal magnitude probe alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e-3</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>labels</key><value>['FFT', 'Scope', 'Waterfall', 'Sensors']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_analog</value></param>
<param><key>labels</key><value>['Analog', 'DC']</value></param>
<param><key>notebook</key><value>nb_right, 0</value></param>
<param><key>style</key><value>wx.NB_LEFT</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_freq</value></param>
<param><key>labels</key><value>['Freq']</value></param>
<param><key>notebook</key><value>nb_right, 0</value></param>
<param><key>style</key><value>wx.NB_LEFT</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_info</value></param>
<param><key>grid_pos</key><value>0, 0, 1, 1</value></param>
<param><key>labels</key><value>['Info']</value></param>
<param><key>notebook</key><value>nb_right, 0</value></param>
<param><key>style</key><value>wx.NB_LEFT</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_rate</value></param>
<param><key>labels</key><value>['Rate']</value></param>
<param><key>notebook</key><value>nb_right, 0</value></param>
<param><key>style</key><value>wx.NB_LEFT</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_right</value></param>
<param><key>grid_pos</key><value>0, 1, 1, 1</value></param>
<param><key>labels</key><value>['Params']</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>nb_test</value></param>
<param><key>labels</key><value>['Test']</value></param>
<param><key>notebook</key><value>nb_right, 0</value></param>
<param><key>style</key><value>wx.NB_LEFT</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>peak_hold</value></param>
<param><key>label</key><value>FFT peak hold</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pps</value></param>
<param><key>label</key><value>Time source (none, internal, external, mimo, gpsdo). &lt;empty&gt; leaves it at the default.</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>analog_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>probe_avg_mag</value></param>
<param><key>alpha</key><value>mag_alpha</value></param>
<param><key>threshold</key><value>0</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>probe_interval</value></param>
<param><key>label</key><value>Signal probe frequency (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ref</value></param>
<param><key>label</key><value>Clock source (internal, external, mimo, gpsdo). &lt;empty&gt; leaves it at the default.</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ref_lvl</value></param>
<param><key>label</key><value>Reference Level</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sensor_interval</value></param>
<param><key>label</key><value>Sensor update frequency (Hz)</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>show_stream_tags</value></param>
<param><key>label</key><value>Print stream tags</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spec</value></param>
<param><key>label</key><value>Sub-device specification (where appropriate)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>''</value></param>
</block>
<block>
<key>shd_smini_source</key>
<param><key>id</key><value>src</value></param>
<param><key>ant0</key><value>selected_antenna_proxy</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>shd.tune_request(freq, lo_offset)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>selected_gain_proxy</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>args</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>clock_source0</key><value></value></param>
<param><key>sd_spec0</key><value>spec</value></param>
<param><key>time_source0</key><value></value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>num_mboards</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>requested_sample_rate</value></param>
<param><key>stream_args</key><value>stream_args</value></param>
<param><key>stream_chans</key><value>[]</value></param>
<param><key>stream_immediately</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>wire_format</value></param>
</block>
<block>
<key>shd_smini_source</key>
<param><key>id</key><value>src_2</value></param>
<param><key>ant0</key><value>selected_antenna_proxy</value></param>
<param><key>bw0</key><value>bw</value></param>
<param><key>center_freq0</key><value>shd.tune_request(freq, lo_offset)</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>selected_gain_proxy</value></param>
<param><key>ant1</key><value>selected_antenna_proxy</value></param>
<param><key>bw1</key><value>bw</value></param>
<param><key>center_freq1</key><value>shd.tune_request(freq, lo_offset)</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>selected_gain_proxy</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>args</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>clock_source0</key><value></value></param>
<param><key>sd_spec0</key><value>spec</value></param>
<param><key>time_source0</key><value></value></param>
<param><key>clock_source1</key><value></value></param>
<param><key>sd_spec1</key><value></value></param>
<param><key>time_source1</key><value></value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>num_mboards</key><value>1</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>requested_sample_rate</value></param>
<param><key>stream_args</key><value>stream_args</value></param>
<param><key>stream_chans</key><value>[]</value></param>
<param><key>stream_immediately</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>otw</key><value>wire_format</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>stream_args</value></param>
<param><key>label</key><value>Stream arguments (e.g. scalar=1024)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>bb2</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2</value></param>
<param><key>stream_id</key><value>bb</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>bb2</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>waterfall_sink</value></param>
<param><key>avg_alpha</key><value>ave</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fft_center_freq</value></param>
<param><key>dynamic_range</key><value>dyn_rng</value></param>
<param><key>fft_rate</key><value>fft_rate</value></param>
<param><key>fft_size</key><value>512*0 + fft_size</value></param>
<param><key>freqvar</key><value>clicked_freq</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>ref_level</key><value>ref_lvl</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window_fn</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>waterfall_sink_0</value></param>
<param><key>avg_alpha</key><value>ave</value></param>
<param><key>average</key><value>True</value></param>
<param><key>baseband_freq</key><value>fft_center_freq</value></param>
<param><key>dynamic_range</key><value>dyn_rng</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fft_rate</key><value>fft_rate</value></param>
<param><key>fft_size</key><value>512*0 + fft_size</value></param>
<param><key>freqvar</key><value>clicked_freq</value></param>
<param><key>fft_in</key><value>False</value></param>
<param><key>notebook</key><value>nb, 2</value></param>
<param><key>fft_out</key><value>False</value></param>
<param><key>ref_scale</key><value>fft_ref_scale</value></param>
<param><key>ref_level</key><value>ref_lvl</value></param>
<param><key>always_run</key><value>False</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>title</key><value>Waterfall Plot 2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>win</key><value>window_fn</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>window</value></param>
<param><key>label</key><value>Window (bh: Blackman-Harris, ham: Hamming, han: Hanning, rect: Rectangular, flat: Flattop)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>auto</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>wire_format</value></param>
<param><key>label</key><value>Wire format (e.g. sc16, sc8) [blank = automatic]</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>notebook</key><value>nb, 1</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot 2</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blks2_logpwrfft_x_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_logpwrfft_x_0</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_selector_0_1</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0</source_block_id><sink_block_id>fft_max_idx_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_argmax_xx_0_0</source_block_id><sink_block_id>fft_max_idx_probe_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blks2_selector_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_0</source_block_id><sink_block_id>blks2_selector_0_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0</source_block_id><sink_block_id>fft_max_lvl_probe</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_max_xx_0_0</source_block_id><sink_block_id>fft_max_lvl_probe_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_argmax_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_max_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0_0</source_block_id><sink_block_id>blocks_argmax_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0_0</source_block_id><sink_block_id>blocks_max_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src_2</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>src_2</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blks2_selector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>fft_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>fft_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>waterfall_sink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>probe_avg_mag</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_1</source_block_id><sink_block_id>baz_time_panel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>blks2_logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>blks2_selector_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>fft_sink_two</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>fft_sink_two_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>logpwrfft_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_2_0</source_block_id><sink_block_id>waterfall_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
